# Autodesk Inventor part: D171EXS_2in
## iProperties
Created: 2011-02
Part Number: D171EXS_2in
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
